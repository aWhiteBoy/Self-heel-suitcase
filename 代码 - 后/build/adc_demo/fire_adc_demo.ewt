<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\Car_Init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\define.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\define.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\fire_drivers_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\fun.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\IAR Embedded Workbench.lnk</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\isr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\app\main.c</name>
    </file>
  </group>
  <group>
    <name>common</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\alloc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\assert.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\io.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\memtest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\printf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\startup.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\stdlib.c</name>
    </file>
  </group>
  <group>
    <name>cpu</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\arm_cm4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\crt0.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\start.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\sysinit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\uif.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\cpu\vectors.c</name>
    </file>
    <configuration>
      <name>Debug</name>
    </configuration>
  </group>
  <group>
    <name>drivers</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\lcd\8x16.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\lcd\8x8h.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\adc\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\delay\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\dma\dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\exti\exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\FTM\FTM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\lcd\GB1616.H</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\lcd\GB3232.H</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\gpio\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\i2c\IIC.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\i2c\IIC.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\lcd\LCD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\lcd\LCD.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\LED\LED.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\lptmr\lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\mcg\mcg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\camera\OV7725.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\camera\OV7725.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\camera\OV7725_REG.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\PIT\PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\port\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\port\port.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\camera\SCCB.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\camera\SCCB.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\uart\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\drivers\wdog\wdog.c</name>
    </file>
    <configuration>
      <name>Debug</name>
    </configuration>
  </group>
  <group>
    <name>header</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\common\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\platforms\k60_fire.h</name>
    </file>
  </group>
</project>


